# Keil uVision project stm32f103_i2c.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: stm32f103_i2c
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\STM32F10x_StdPeriph_Driver\inc;.\STM32F10x_StdPeriph_Driver\src;..\stm32f103_i2c;.\CMSIS\CM3\CoreSupport;.\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;.\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\MPU9250;.\Kalman;.\SSD1306
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: Main.cpp usart_print.cpp
  group CMSIS
    ./CMSIS/CM3/CoreSupport/: core_cm3.c
  group LIbrary
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c
  group MPU9250
    ./MPU9250/: MPU9250.cpp MPU9250.h
  group Kalman
    ./Kalman/: Kalman.c
  group SSD1306
    ./SSD1306/: SSD1306.cpp
  group ::Device
    RTE/Device/STM32F103C8/: RTE_Device.h startup_stm32f10x_md.s system_stm32f10x.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
